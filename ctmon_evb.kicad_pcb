# Repository y-suyama/CTMON_EVB

## KiCad design ctmon_evb.kicad_pcb

Parts:
C1, C14: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C5, C7, C8, C11, C12, C13, C15, C17, C18, C19, C21, C22, C23, C24, C25, C28, C29, C31, C34, C37, C39, C40, C41, C43, C44, C45, C46, C47: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C3, C6, C16, C27, C30, C38: 0.01uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C9, C20, C42: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10: 22pF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C32, C35, C36: 0.1uF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; not fitted
C33: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; not fitted
D1, D4: LESD5D5-0CT1G; D_SOD-523
D2: XL-1005UYC; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D3: XL-1005UWC; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D6: XL-1005UBC; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
F1: K1812L30012DR
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom
J1: Conn_02x01; PinHeader_2x01_P2.54mm_Vertical
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J3: HB9500M-9.5-8P; CONN_HB9500-9.5-8P_KAN
J5: UJC-HP-3-SMT-TR; CUI_UJC-HP-3-SMT-TR; PARTREV 04/30/2020
L1, L2: HCB1005KF-121T20; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
Q1, Q2: NMOS; SOT-23_Handsoldering
Q3: 30N06; TO-252-2
R1, R3, R17, R18, R20, R21, R30, R39, R44, R45: 10k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R2, R9, R12: 4.7k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R7, R8, R24, R25, R36, R49, R50: 510; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R10, R11: 5.1k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R14, R15, R60, R61, R62, R63: 2.2k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; not fitted
R16, R19, R22, R23, R26, R35, R38, R56, R57, R58, R59, R64, R65, R66, R67: 2.2k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R27: 10M; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R28: 56; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R29: 190k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R31, R32: 10k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; not fitted
R37: 510; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; not fitted
R40: 0; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R41, R42: 0; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder; not fitted
R43: 100m; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R46, R47: 15k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R48: 0; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
TP1, TP3, TP5, TP7: RH-5117; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP2, TP4, TP6, TP8: RH-5001; TestPoint_THTPad_D2.5mm_Drill1.2mm
U1, U3, U5, U7, U13, U15, U16, U17: OPA333xxDBV; SOT-23-5
U2: CC6920SO-20A; SO-8_3.9x4.9mm_P1.27mm
U4, U12: ADS1115IDGSR; DGS0010A_M
U6, U10: CC6920SO-10A; SO-8_3.9x4.9mm_P1.27mm
U8: MCP4725xxx-xCH; SOT-23-6
U9, U11: OPA333xxDBV; SOT-23-5; not fitted
U14: CC6920SO-5A; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V_FIL: C14.1, L2.1, Q1.1 (G), Q2.1 (G), R12.1, R14.1, R15.1
+5V_FIL: C1.1, C3.1, C4.1, C6.1, C7.1, C8.1, C11.1, C16.1, C18.1, C19.1, C22.1, C25.1, C27.1, C28.1, C30.1, C31.1, C32.1, C35.1, C38.1, C40.1, C41.1, C44.1, L1.1, R2.1, R16.1, R22.1, R39.1, U1.5 (V+), U2.8 (VCC), U3.5 (V+), U4.8 (VDD), U5.5 (V+), U6.8 (VCC), U7.5 (V+), U8.3 (VDD), U9.5 (V+), U10.8 (VCC), U11.5 (V+), U12.8 (VDD), U13.5 (V+), U14.8 (VCC), U15.5 (V+)
+5V_USB: C21.1, C34.1, C47.1, F1.1, R48.1, U16.5 (V+), U17.5 (V+)
EVBDET_N: J2.4, R19.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C43.2, C44.2, C45.2, C46.2, C47.2, D1.2 (A2), D2.1 (K), D3.1 (K), D4.2 (A2), D6.1 (K), J1.2, J2.5, J2.6, J5.A12 (GND), J5.B12 (GND__1), J5.S1 (SHIELD), J5.S2 (SHIELD__1), J5.S3 (SHIELD__2), J5.S4 (SHIELD__3), R10.2, R11.2, R17.2, R19.2, R30.2, R43.2, TP2.1, TP4.1, TP6.1, TP8.1, U1.2 (V-), U2.5 (GND), U3.2 (V-), U4.3 (GND), U5.2 (V-), U6.5 (GND), U7.2 (V-), U8.2 (VSS), U8.6 (A0), U9.2 (V-), U10.5 (GND), U11.2 (V-), U12.3 (GND), U13.2 (V-), U14.5 (GND)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
I2CSCL_3.3V: J2.1, Q1.2 (S), R14.2, R41.1
I2CSCL_5V: Q1.3 (D), R16.2, R41.2, U4.10 (SCL), U8.5 (SCL), U12.10 (SCL)
I2CSDA_3.3V: J2.2, Q2.2 (S), R15.2, R42.1
I2CSDA_5V: Q2.3 (D), R22.2, R42.2, U4.9 (SDA), U8.4 (SDA), U12.9 (SDA)
IP+_1: J3.1, U2.1 (IP+), U2.2 (IP+)
IP+_2: J3.3, U6.1 (IP+), U6.2 (IP+)
IP+_3: J3.5, U10.1 (IP+), U10.2 (IP+)
IP+_4: J3.7, U14.1 (IP+), U14.2 (IP+)
IP-_1: J3.2, U2.3 (IP-), U2.4 (IP-)
IP-_2: J3.4, U6.3 (IP-), U6.4 (IP-)
IP-_3: J3.6, U10.3 (IP-), U10.4 (IP-)
IP-_4: J3.8, U14.3 (IP-), U14.4 (IP-)
unnamed: C10.2, R27.2, R28.1, U16.1
unnamed: C2.1, D1.1 (A1), J1.1, L1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R12.2
unnamed: C43.1, D4.1 (A1), F1.2, J5.A9 (V-BUS), J5.B9 (V-BUS__1), R9.1
unnamed: D6.2 (A), R9.2
unnamed: C15.1, J2.3, L2.2
unnamed: J5.A5 (CC1), R10.1
unnamed: J5.B5 (CC2), R11.1
unnamed: Q3.2 (D), R48.2
unnamed: Q3.1 (G), R28.2
unnamed: Q3.3 (S), R43.1, R47.2
unnamed: R1.2, R8.1, R23.2, R35.2, U3.1
unnamed: R18.2, R25.1, R56.2, R57.2, U7.1
unnamed: R24.1, R58.2, R59.2, U5.1
unnamed: R7.1, R26.2, R38.2, U1.1
unnamed: R29.1, R46.2, U17.1
unnamed: R31.2, R37.1, R60.2, R61.2, U11.1
unnamed: R36.1, R40.2, R62.2, R63.2, U9.1
unnamed: R44.2, R50.1, R64.2, R65.2, U15.1
unnamed: R49.1, R66.2, R67.2, U13.1
unnamed: R1.1, R3.2, U1.3 (+)
unnamed: R26.1, R35.1, U1.4 (-)
unnamed: R3.1, TP1.1, U2.7 (OUT)
unnamed: R23.1, R38.1, U3.4 (-)
unnamed: R17.1, U4.1 (ADDR)
unnamed: C5.1, C9.2, R7.2, U4.4 (AIN0)
unnamed: C9.1, C12.1, R8.2, U4.5 (AIN1)
unnamed: C17.1, C20.2, R24.2, U4.6 (AIN2)
unnamed: C20.1, C23.1, R25.2, U4.7 (AIN3)
unnamed: R18.1, R20.2, U5.3 (+)
unnamed: R56.1, R58.1, U5.4 (-)
unnamed: R20.1, TP3.1, U6.7 (OUT)
unnamed: R57.1, R59.1, U7.4 (-)
unnamed: R21.1, U8.1 (VOUT)
unnamed: R31.1, R32.2, U9.3 (+)
unnamed: R60.1, R62.1, U9.4 (-)
unnamed: R32.1, R40.1, TP5.1, U10.7 (OUT)
unnamed: R61.1, R63.1, U11.4 (-)
unnamed: R39.2, U12.1 (ADDR)
unnamed: C29.1, C33.2, R36.2, U12.4 (AIN0)
unnamed: C33.1, C36.1, R37.2, U12.5 (AIN1)
unnamed: C39.1, C42.2, R49.2, U12.6 (AIN2)
unnamed: C42.1, C45.1, R50.2, U12.7 (AIN3)
unnamed: R44.1, R45.2, U13.3 (+)
unnamed: R64.1, R66.1, U13.4 (-)
unnamed: R45.1, TP7.1, U14.7 (OUT)
unnamed: R65.1, R67.1, U15.4 (-)
unnamed: R21.2, R27.1, U16.3 (+)
unnamed: C10.1, R46.1, U16.4 (-)
unnamed: R47.1, U17.3 (+)
unnamed: R29.2, R30.1, U17.4 (-)
VZCR_1: C13.1, U2.6 (VZCR), U3.3 (+)
VZCR_2: C24.1, U6.6 (VZCR), U7.3 (+)
VZCR_3: C37.1, U10.6 (VZCR), U11.3 (+)
VZCR_4: C46.1, U14.6 (VZCR), U15.3 (+)

Notes on the sheet:
BLUE LED
DAC 12bit
0.9mΩtyp
5Amax
load
400mV/A
SLAVE ADDRESS 1001000
Pinheader & Power LED
ADC入力の0.1uFが駆動出来なければ 容量を下げてアンチエイリアスFIL の定数全て見直し
200mV/A
Ihold = 3A Itrip = 6A
SLAVE ADDRESS 1100000
10Amax
CC69XX下部はランドなし長孔 部品面、半田面は長孔周辺のベタ禁止 分かりやすい位置に許容電流表示すること
I2C Level Shift(5V ⇔ 3.3V)
20Amax
VBR = 5.6Vmin
OPA333 Rail to Rail, チョッピング周波数125kHz
Through hole M3
VBR=5.6Vmin
SLAVE ADDRESS 1001001
Current source & USB External Power
White LED
基板の四隅に配置 未接続
Yellow LED
100mV/A

Board: 2 copper layers, 100.0 x 100.0 mm, 146 parts (11 on the bottom side), 73 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_4, _3, _2, ",,4,,
"C1, C14",0603,2,22uF,
C10,0201,1,22pF,
"C11, C12, C13, C15, C17, C18, C19, C2, C21, C22, C23, C24, C25, C28, C29, C31, C32, C34, C35, C36, C37, C39, C4, C40, C41, C43, C44, C45, C46, C47, C5, C7, C8",0201,33,0.1uF,
"C16, C27, C3, C30, C38, C6",0201,6,0.01uF,
"C20, C33, C42, C9",0402,4,1uF,
"D1, D4",D_SOD-523,2,LESD5D5-0CT1G,
D2,0402,1,XL-1005UYC,
D3,0402,1,XL-1005UWC,
D6,0402,1,XL-1005UBC,
F1,K1812L30012DR,1,K1812L30012DR,
J1,PinHeader_2x01_P2.54mm_Vertical,1,Conn_02x01,
J2,PinHeader_2x03_P2.54mm_Vertical,1,Conn_02x03_Odd_Even,
J3,CONN_HB9500-9.5-8P_KAN,1,HB9500M-9.5-8P,
J5,CUI_UJC-HP-3-SMT-TR,1,UJC-HP-3-SMT-TR,
"L1, L2",0402,2,HCB1005KF-121T20,
"Q1, Q2",SOT-23_Handsoldering,2,NMOS,
Q3,TO-252-2,1,30N06,
"R1, R17, R18, R20, R21, R3, R30, R31, R32, R39, R44, R45",0201,12,10k,
"R10, R11",0201,2,5.1k,
"R12, R2, R9",0201,3,4.7k,
"R14, R15, R16, R19, R22, R23, R26, R35, R38, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67",0201,21,2.2k,
"R24, R25, R36, R37, R49, R50, R7, R8",0201,8,510,
R27,0201,1,10M,
R28,0201,1,56,
R29,0402,1,190k,
"R40, R41, R42",0201,3,0,
R43,2512,1,100m,
"R46, R47",0201,2,15k,
R48,2512,1,0,
"TP1, TP3, TP5, TP7",TestPoint_THTPad_D2.5mm_Drill1.2mm,4,RH-5117,
"TP2, TP4, TP6, TP8",TestPoint_THTPad_D2.5mm_Drill1.2mm,4,RH-5001,
"U1, U11, U13, U15, U16, U17, U3, U5, U7, U9",SOT-23-5,10,OPA333xxDBV,
"U10, U6",SO-8_3.9x4.9mm_P1.27mm,2,CC6920SO-10A,
"U12, U4",DGS0010A_M,2,ADS1115IDGSR,
U14,SO-8_3.9x4.9mm_P1.27mm,1,CC6920SO-5A,
U2,SO-8_3.9x4.9mm_P1.27mm,1,CC6920SO-20A,
U8,SOT-23-6,1,MCP4725xxx-xCH,
